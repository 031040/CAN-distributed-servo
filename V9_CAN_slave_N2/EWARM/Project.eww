<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\V0_LED_闪烁.ewp</path>
  </project>
  <batchBuild />
</workspace>
